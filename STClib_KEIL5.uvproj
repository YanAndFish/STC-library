# Keil uVision project STClib_KEIL5.uvproj, settings and files
target STC15 (MCS-51)
  device: STC15W4K32S4 STC
  cpu: IRAM(0-0xFF) XRAM(0-0xEFF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STClib_KEIL5 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC15,CLOCK=24000000
  c include: .\src;.\src\CORE;.\src\HAL;.\src\DRIVER;.\src\HAND
  link misc: REMOVEUNUSED
  group USER_APP
    ./: main.c README.md
  group HAL
    ./src/HAL/: HAL_ADC.c HAL_DELAY.c HAL_EXTI.c HAL_GPIO.c HAL_IAP.c HAL_IIC.c HAL_PCA.c HAL_POWER.c HAL_PWM.c HAL_SPI.c HAL_TIMER.c HAL_UART.c HAL_WDT.c
  group DRIVER
    ./src/DRIVER/: KeyBoard.c RgbLed.c DHT11.c
  group core
    ./src/core/: core.c
    ./src/CORE/: interrupt.c bitctrl.c
target STC8 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STClib_KEIL5 +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC8,CLOCK=24000000
  c include: .\src;.\src\CORE;.\src\HAL;.\src\DRIVER;.\src\HAND
  link misc: REMOVEUNUSED
